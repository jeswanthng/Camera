# Keil uVision project CAMERA.uvproj, settings and files
target LPC17xx Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CAMERA +hex
  c flags: Optim=1
  c include: ..\..\CAM_PROJECT;..\CONFIG\INC;..\DRIVERS\UART\INC;..\DRIVERS\TIMER\INC;..\DRIVERS\CAMERA\INC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ../APP/SRC/: main.c
    ../DRIVERS/UART/SRC/: uart.c
    ../DRIVERS/TIMER/SRC/: timer.c
    ../DRIVERS/CAMERA/SRC/: camera.c
    ../DRIVERS/GPRS/SRC/: gprs.c
  group Startup
    ../CONFIG/INC/: startup_LPC17xx.s
  group Common
    ../CONFIG/SRC/: system_LPC17xx.c
target LPC17xx RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
